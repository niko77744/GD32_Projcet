# Keil uVision project GD32H757.uvprojx, settings and files
target LED (5060960::V5.06 update 7 (build 960)::.\arm5_compiler)
  device: GD32H757ZM GigaDevice
  pack: GigaDevice.GD32H7xx_DFP.1.1.0
  cpu: IRAM(0x24000000,0x000E0000) IRAM2(0x00000000,0x00010000) IROM(0x08000000,0x03C0000) XRAM(0x20000000,0x00010000) XRAM2(0x30000000,0x00004000) XRAM3(0x30004000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: GD32H757 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=5 wLevel=2
  c define: GD32H7XX
  c include: ..\..\Drivers\CMSIS;..\..\Drivers\CMSIS\GD\GD32H7xx\Include;..\..\Drivers\GD32H7xx_standard_peripheral\Include;..\..\Drivers;..\..\Middlewares;..\..\User;..\..\Middlewares\MultiButton-master;..\..\Middlewares\EasyLogger\easylogger\inc;..\..\Middlewares\EasyLogger\easylogger\plugins\file;..\..\Middlewares\EasyLogger\easylogger\plugins\flash;..\..\Middlewares\EasyFlash\easyflash\inc
  memory RVCT4: ROM 0x8000000 size 0x3c0000
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT7: RAM 0x30000000 size 0x4000
  memory RVCT8: RAM 0x30004000 size 0x4000
  memory RVCT9: RAM 0x24000000 size 0xe0000
  memory RVCT10: RAM 0x0 size 0x10000
  group Startup
    ../../Drivers/CMSIS/GD/GD32H7xx/Source/ARM/: startup_gd32h7xx.s
  group User
    ../../User/: main.c gd32h7xx_it.c
    ../../Drivers/CMSIS/GD/GD32H7xx/Source/: system_gd32h7xx.c
  group Middlewares/MultiButton
    ../../Middlewares/MultiButton-master/: multi_button.c
  group Middlewares/Easy_Logger
    ../../Middlewares/EasyLogger/easylogger/port/: elog_port.c
    ../../Middlewares/EasyLogger/easylogger/plugins/file/: elog_file_port.c elog_file.c elog_file.h elog_file_cfg.h
    ../../Middlewares/EasyLogger/easylogger/plugins/flash/: elog_flash_port.c elog_flash.c elog_flash.h elog_flash_cfg.h
    ../../Middlewares/EasyLogger/easylogger/src/: elog.c elog_utils.c elog_async.c elog_buf.c
    ../../Middlewares/EasyLogger/easylogger/inc/: elog.h elog_cfg.h
  group Middlewares/Easy_Flash
    ../../Middlewares/EasyFlash/easyflash/src/: easyflash.c ef_env.c ef_env_legacy.c ef_env_legacy_wl.c ef_iap.c ef_log.c ef_utils.c
    ../../Middlewares/EasyFlash/easyflash/port/: ef_port.c
    ../../Middlewares/EasyFlash/easyflash/inc/: easyflash.h ef_def.h ef_cfg.h
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/GD32H7xx_standard_peripheral
    ../../Drivers/GD32H7xx_standard_peripheral/Source/: gd32h7xx_adc.c gd32h7xx_can.c gd32h7xx_cau.c gd32h7xx_cau_aes.c gd32h7xx_cau_des.c gd32h7xx_cau_tdes.c gd32h7xx_cmp.c gd32h7xx_cpdm.c gd32h7xx_crc.c gd32h7xx_ctc.c gd32h7xx_dac.c gd32h7xx_dbg.c gd32h7xx_dci.c gd32h7xx_dma.c gd32h7xx_edout.c gd32h7xx_efuse.c gd32h7xx_exmc.c gd32h7xx_exti.c gd32h7xx_fac.c gd32h7xx_fmc.c gd32h7xx_fwdgt.c gd32h7xx_gpio.c gd32h7xx_hau.c gd32h7xx_hau_sha_md5.c gd32h7xx_hpdf.c gd32h7xx_hwsem.c gd32h7xx_i2c.c gd32h7xx_ipa.c gd32h7xx_lpdts.c gd32h7xx_mdio.c gd32h7xx_mdma.c gd32h7xx_misc.c gd32h7xx_ospi.c gd32h7xx_ospim.c gd32h7xx_pmu.c gd32h7xx_rameccmu.c gd32h7xx_rcu.c gd32h7xx_rspdif.c gd32h7xx_rtc.c gd32h7xx_rtdec.c gd32h7xx_sai.c gd32h7xx_sdio.c gd32h7xx_spi.c gd32h7xx_syscfg.c gd32h7xx_timer.c gd32h7xx_tli.c gd32h7xx_tmu.c gd32h7xx_trigsel.c gd32h7xx_trng.c gd32h7xx_usart.c gd32h7xx_vref.c gd32h7xx_wwdgt.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/Button/: Button.c
  group Readme
    ../../: readme.txt
